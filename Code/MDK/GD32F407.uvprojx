# Keil uVision project GD32F407.uvprojx, settings and files
target GD32F4 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F407VG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32F407 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F407
  c include: ..\CORE\Inc;..\DRIVER\CMSIS\Include;..\DRIVER\CMSIS\Device\GD\GD32F4xx\Include;..\DRIVER\GD32_Driver\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group application
    ../CORE/Src/: gd32f4xx_it.c main.c systick.c can.c dma.c gpio.c usart.c adc.c
  group library
    ../DRIVER/GD32_Driver/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group cmsis
    ../DRIVER/CMSIS/Device/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group startup
    ../DRIVER/CMSIS/Device/GD/GD32F4xx/Source/ARM/: startup_gd32f407.s
